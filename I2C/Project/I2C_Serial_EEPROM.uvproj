# Keil uVision project I2C_Serial_EEPROM.uvproj, settings and files
target LPC2100 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: I2C_Serial_EEPROM +hex
  AfterMake: fromelf --bin ./Obj/I2C_Serial_EEPROM.axf -o ./Obj/I2C_Serial_EEPROM.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c i2c.c lcd.c extn_int.c
  group Documentation
    ./: Abstract.txt
